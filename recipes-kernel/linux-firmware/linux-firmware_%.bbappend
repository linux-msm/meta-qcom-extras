# temporal workaround until this RPROVIDES is merged into OE-Core
RPROVIDES:${PN}-qcom-qcm6490-wifi:qcom = "${PN}-qcom-qcs6490-wifi"
