# Inforce / Penguin Edge devkits
PACKAGE_INSTALL += " \
    packagegroup-ifc6560-firmware \
"
