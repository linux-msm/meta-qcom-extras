# WoA devices
PACKAGE_INSTALL += " \
    packagegroup-ecs-liva-qc710-firmware \
    packagegroup-lenovo-miix-630-firmware \
    packagegroup-lenovo-yoga-c630-firmware \
    packagegroup-lenovo-x13s-firmware \
    packagegroup-sc8180x-firmware \
    packagegroup-x1e80100-crd-firmware \
"
